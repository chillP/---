# Keil uVision project GWTESTS1.uvprojx, settings and files
target GWTESTS1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L071CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: GWTESTS1 +hex
  AfterMake: D:\developSoftware\MDK5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\OBJ\APP.bin  .\@L\@L.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L071xx
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\SX1301\src;..\SX1301\tst;..\SX1301\inc;..\AnalysisTool;..\ConfigTool;..\AES
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x1a000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
  group SX1301
    ../SX1301/tst/: sx1301_rx_tx.c util_tx_test.c
    ../SX1301/src/: loragw_aux.c loragw_fpga.c loragw_hal.c loragw_lbt.c loragw_radio.c loragw_reg.c loragw_spi.c loragw_user.c
  group AnalysisTool
    ../AnalysisTool/: AnalysisTool.c led.c protocol_analysis.c rf_rxtx_debug.c softwareversion.c test_tool.c p2p.c PC_Seting.c
  group ConfigTool
    ../ConfigTool/: CT_funtion.c ConfigTool.c
  group Application/User
    ../Src/: main.c gpio.c crc.c dma.c rtc.c spi.c tim.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group AES
    ../AES/: aes.c
software components: CMSIS:CORE 4.3.0
